ORG  0000H
LJMP MAIN


ORG 000BH
	
	MOV A,R3
	ACALL CONVERT
	SETB P1.0
	ACALL DELAY
	CLR P1.0
	
	MOV A,R2
	ACALL CONVERT
	SETB P1.1
	ACALL DELAY
	CLR P1.1
	
	MOV A,R1
	ACALL CONVERT
	SETB P1.2
	ACALL DELAY
	CLR P1.2
			
	MOV A,R0
	ACALL CONVERT
	SETB P1.3
	ACALL DELAY
	CLR P1.3

	MOV TL0,#066H
	MOV TH0,#0FCH

	RETI

MAIN:	

	   MOV R0,#3									   
	   MOV R1,#2
	   MOV R2,#1
	   MOV R3,#0

	   MOV P0,#00H
	   MOV P1,#00H
	   MOV TMOD,#01H
	   MOV TL0,#066H
	   MOV TH0,#0FCH
	   MOV IE,#82H
	   SETB TR0
	   SJMP $

DELAY:	MOV TL0,#066H
	   	MOV TH0,#0FCH
FF:		JNB TF0,FF
		CLR TF0
		RET
		   

CONVERT:	CJNE A,#0,NEXT
			MOV P0,#40H
			RET 		
NEXT:		CJNE A,#1,NEXT1
			MOV P0,#79H
			RET
NEXT1:		CJNE A,#2,NEXT2
			MOV P0,#24H
			RET
NEXT2:		CJNE A,#3,NEXT3
			MOV P0,#30H
			RET
NEXT3:		CJNE A,#4,NEXT4
			MOV P0,#19H
			RET
NEXT4:		CJNE A,#5,NEXT5
			MOV P0,#12H
			RET
NEXT5:		CJNE A,#6,NEXT6
			MOV P0,#02H
			RET
NEXT6:		CJNE A,#7,NEXT7
			MOV P0,#78H
			RET
NEXT7:		CJNE A,#8,NEXT8
			MOV P0,#00H
			RET
NEXT8:		CJNE A,#9,NEXT9
			MOV P0,#10H
NEXT9:		RET
END
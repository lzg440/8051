# Keil uVision project new.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LV51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: new
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: new.c

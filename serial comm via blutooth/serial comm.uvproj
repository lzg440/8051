# Keil uVision project serial comm.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LV51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: serial comm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: serial comm.c
